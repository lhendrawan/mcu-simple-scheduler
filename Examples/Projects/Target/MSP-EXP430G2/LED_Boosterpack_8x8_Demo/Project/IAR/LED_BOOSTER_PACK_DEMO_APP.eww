<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LED_BOOSTER_PACK_DEMO_APP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


