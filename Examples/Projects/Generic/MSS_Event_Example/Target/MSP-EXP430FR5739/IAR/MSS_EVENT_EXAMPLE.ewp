# IAR project MSS_EVENT_EXAMPLE.ewp, settings and files
configuration MSP-EXP430FR5739 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\Configuration; ..\..\..\Source; ..\..\..\..\..\..\hal\MSP-EXP430FR5739; ..\..\..\..\..\..\..\Sources\llist; ..\..\..\..\..\..\..\Sources\mss\common; ..\..\..\..\..\..\..\Sources\mss\target\MSP-EXP430FR5739
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5739.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../../Source/: event_app.c event_app.h
  group hal/MSP-EXP430FR5739
    ../../../../../../hal/MSP-EXP430FR5739/: hal.c hal.h
  group mss_source/cfg
    ../../../Configuration/: llist_cfg.h mss_cfg.h
  group mss_source/llist
    ../../../../../../../Sources/llist/: llist.c llist.h
  group mss_source/mss/common
    ../../../../../../../Sources/mss/common/: mss.c mss.h mss_event.c mss_event.h mss_int.h mss_mem.c mss_mem.h mss_mque.c mss_mque.h mss_sema.c mss_sema.h mss_timer.c mss_timer.h
  group mss_source/mss/target/MSP-EXP430FR5739
    ../../../../../../../Sources/mss/target/MSP-EXP430FR5739/: dev_types.h mss_hal.c mss_hal.h mss_hal_int.h
